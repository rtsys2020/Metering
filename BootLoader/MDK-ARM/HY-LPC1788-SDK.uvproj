# Keil uVision project HY-LPC1788-SDK.uvproj, settings and files
target Project_ST-X (ARM-ADS)
  device: LPC1788 NXP (founded by Philips)
  cpu: IRAM(0x10000000-0x1000FFFF) IRAM2(0x20000000-0x20007FFF) IROM(0-0x7FFFF) CLOCK(12000000) CPUTYPE("Cortex-M3")
  output: Project_ST-X +hex
  AfterMake: fromelf -c ./Obj/Project_ST-X.axf --output ./List/Project_ST-X.txt
  c flags: Optim=1 wLevel=1
  c define: _DEBUG_,_UCOS_,__CHECK_DEVICE_DEFINES
  c include: ..\USER;..\..\Common\lpc177x.lpc178x.cmsis.driver.library_2012.8.13\Drivers\include;..\..\Common\lpc177x.lpc178x.cmsis.driver.library_2012.8.13\Core\CMSIS\Include;..\..\Common\lpc177x.lpc178x.cmsis.driver.library_2012.8.13\Core\Device\NXP\LPC177x_8x\Include;..\..\Common\lpc177x.lpc178x.cmsis.driver.library_2012.8.13\BoardSupport;..\USER\User_App;..\USER\Peripheral\inc;..\USER\common\inc;..\USER\Flash-RTC\inc;..\USER\IRQ_Handeler\inc;..\USER\crypt_lib\inc;..\USER\BootApp\inc;..\USER\firmware\inc
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT6: RAM 0xa0000000 size 0x2000000
  memory RVCT9: RAM 0x10000000 size 0x10000
  memory RVCT10: RAM 0x20000000 size 0x8000
  scatter file: .\List\Project_ST-X.sct
  group lpc177x.lpc178x.cmsis.driver.library_2012.8.13
    ../../Common/lpc177x.lpc178x.cmsis.driver.library_2012.8.13/Drivers/source/: debug_frmwrk.c lpc177x_8x_clkpwr.c lpc177x_8x_gpio.c lpc177x_8x_nvic.c lpc177x_8x_pinsel.c lpc177x_8x_uart.c lpc177x_8x_crc.c lpc177x_8x_exti.c lpc177x_8x_gpdma.c lpc177x_8x_iap.c lpc177x_8x_ssp.c lpc177x_8x_systick.c lpc177x_8x_wwdt.c lpc177x_8x_emc.c
  group CMSIS
    ../../Common/lpc177x.lpc178x.cmsis.driver.library_2012.8.13/Core/Device/NXP/LPC177x_8x/Source/Templates/: system_LPC177x_8x.c
  group Startup
    ../../Common/lpc177x.lpc178x.cmsis.driver.library_2012.8.13/Core/Device/NXP/LPC177x_8x/Source/Templates/ARM/: startup_LPC177x_8x.s
  group Doc
    ../: readme.txt
  group common
    ../USER/common/src/: ssp_driver.c
  group RTC_FLASH
    ../USER/Flash-RTC/src/: at45db32.c
  group IRQ_Handeler
    ../USER/IRQ_Handeler/src/: fault_IRQ.c EXTIT_Handeler.c GPIO_IRQHandler.c
  group User
    ../USER/: main.c
    ../USER/common/inc/: includes.h
  group Crypt
    ../USER/crypt_lib/src/: crypt.c crypt_aes128.c crypt_aes192.c crypt_aes256.c cypher.c decrypt.c decrypt_aes128.c fips197_test_keys.c gen_aes128_expkey.c gen_aes192_expkey.c gen_aes256_expkey.c init_crypt.c init_decrypt.c
  group bootloader
    ../USER/BootApp/src/: lpc17xx_sector.c flashprogram.c
    ../USER/BootApp/inc/: lpc17xx_sector.h
    ../USER/firmware/src/: firmware.c
