# Keil uVision project Gpio_Output.uvproj, settings and files
target FLASH (ARM-ADS)
  device: LPC1788 NXP (founded by Philips)
  cpu: IRAM(0x10000000-0x1000FFFF) IRAM2(0x20000000-0x20007FFF) IROM(0-0x7FFFF) CLOCK(12000000) CPUTYPE("Cortex-M3")
  output: Gpio_Output +hex
  c flags: Optim=1 wLevel=2
  c define: _UC_OS_
  c include: ..\..\Common\lpc177x.lpc178x.library_2012.8.13\Drivers\include;..\..\Common\lpc177x.lpc178x.library_2012.8.13\Core\Device\NXP\LPC177x_8x\Include;..\USER\common\inc;..\USER\IRQ_Handeler\inc;..\USER\fatfs\inc;..\USER\ucCos_App;..\USER\User_App;..\USER\SwitchPin\inc;..\USER\Config;..\USER\uC-OSII\ucCos_App;..\USER\uC-OSII\;..\USER\Tasks\inc;..\USER\HDLC\inc;..\USER\Flash-RTC\inc;..\USER\RTC;..\USER\ADE7953;..\USER\manipulation;..\USER\IRQ_Handeler\inc
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x10000
  memory RVCT10: RAM 0x20000000 size 0x8000
  group Startup
    ../../Common/lpc177x.lpc178x.library_2012.8.13/Core/Device/NXP/LPC177x_8x/Source/Templates/ARM/: startup_LPC177x_8x.s
    ../../Common/lpc177x.lpc178x.library_2012.8.13/Core/Device/NXP/LPC177x_8x/Source/Templates/: system_LPC177x_8x.c
  group Drivers
    ../../Common/lpc177x.lpc178x.library_2012.8.13/Drivers/source/: debug_frmwrk.c lpc177x_8x_clkpwr.c lpc177x_8x_exti.c lpc177x_8x_gpdma.c lpc177x_8x_gpio.c lpc177x_8x_i2c.c lpc177x_8x_mci.c lpc177x_8x_pinsel.c lpc177x_8x_pwm.c lpc177x_8x_rtc.c lpc177x_8x_ssp.c lpc177x_8x_systick.c lpc177x_8x_uart.c lpc177x_8x_wwdt.c
  group Main
    ../USER/: main.c
  group BSP
    ../USER/User_App/: user_bsp.c
  group Config
    ../USER/User_App/: user_bsp.h
    ../USER/Tasks/inc/: DailyMeterRecord.h applicationtask.h AlarmMangment.h IHD_Task.h irqhandlertask.h LimitAndManageBar.h loadprofil_task.h sourceonoff.h tariff_task.h
  group uC-OS-II/Port
    ../USER/uC-OSII/uCOS-II/Ports/ARM-Cortex-M3/RealView/: os_cpu.h os_cpu_a.asm os_cpu_c.c os_dbg.c
  group uC-OS-II/Source
    ../USER/uC-OSII/uCOS-II/Source/: os_core.c os_flag.c os_mbox.c os_mem.c os_mutex.c os_q.c os_sem.c os_task.c os_time.c os_tmr.c os_cfg_r.h ucos_ii.h
  group uC-OS-II/Config
    ../USER/uC-OSII/ucCos_App/: OS_AppHooks.c os_cfg.h
  group Tasks
    ../USER/Tasks/src/: ApplicatonTask.c DailyMeterRecord.c LimitAndManageBar.c IHD_Task.c AlarmMangment.c loadprofil_task.c sourceonoff.c tariff_task.c dummyTask.c IRQHandelTask.c
  group Common
    ../USER/common/src/: ssp_driver.c i3c.c osinital.c list.c list_iterator.c list_node.c
  group SPI_Flash
    ../USER/Flash-RTC/src/: at45db32.c
    ../USER/Flash-RTC/inc/: at45db32.h
  group RTC
    ../USER/RTC/src/: RTC_BSP.c
  group ADE7953
    ../USER/ADE7953/src/: ade7953_i2c_driver.c ADE7953_spi_driver.c
  group manipulation
    ../USER/manipulate/: manipulate.c
  group FileSystem
    ../USER/fatfs/: diskio.c ff.c filesystem.c fs_mci.c rtc_cfg.c
    ../USER/fatfs/option/: ccsbcs.c syscall.c
  group IRQ_handel
    ../USER/IRQ_Handeler/src/: EXTIT_Handeler.c GPIO_IRQHandler.c
target RAM (ARM-ADS)
  device: LPC1788 NXP (founded by Philips)
  cpu: as above
  output: Gpio_Output +hex
  c flags: Optim=1 wLevel=2
  c define: __RAM_MODE__
  c include: ..\..\..\..\Drivers\include;..\..\..\..\BoardSupport;..\..\..\..\Core\CMSIS\Include;..\..\..\..\Core\Device\NXP\LPC177x_8x\Include
  library: MicroLIB
  memory RVCT4: ROM 0x10000000 size 0x8000
  memory RVCT9: RAM 0x10008000 size 0x8000
  memory RVCT10: RAM 0x20000000 size 0x8000
